# IAR project Backup of LCD_PROGEK.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: C:\Users\ser\Cloud@Mail.Ru\STM32\LCD\stm_lib\inc; C:\Users\ser\Cloud@Mail.Ru\STM32\LCD\src; C:\Users\ser\Cloud@Mail.Ru\STM32\LCD\DeviceSupport; C:\Users\ser\Cloud@Mail.Ru\STM32\LCD\cmsis
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LCD_PROGEK.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: LCD_PROGEK.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    Src/: Delay.c ds1820.c I2C.c LCD_I2C.c main.c
  group src
    stm_lib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c
    DeviceSupport/: startup_stm32f10x_md_vl.s system_stm32f10x.c
